Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Fabio-35.IFC
Time: 2016-10-31T12:39:43
Written by: SwIFC
Made in: SolidWorks 2016

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 mm

# IfcBuildingElementProxy: Fabio-35
In: Default Storey
Material: Steel
PSet_Type_Identity_Data - OmniClass Number: 23.80.70.11.14.11; OmniClass Title: Downlights
PSet_Mass_Property - Mass Measure: 39.6617; Area Measure: 9538.78 m2; Volume Measure: 39661.7 m3
